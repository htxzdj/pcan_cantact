# Keil uVision project canable_pcan.uvprojx, settings and files
target canable_pcan (6150000::V6.15::ARMCLANG)
  device: STM32F072C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: canable_pcan +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=4 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32F072xB,NDEBUG
  c include: ..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\Drivers\STM32F0xx_HAL_Driver\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\Src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Drivers/STM32F0x2_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_can.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_exti.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_i2c.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_tim.c stm32f0xx_ll_usb.c stm32f0xx_ll_utils.c
  group Drivers/STM32F0x2_USB_Driver
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group User
    ../Src/: main.c pcan_can.c pcan_led.c pcan_protocol.c pcan_timestamp.c pcan_usb.c system_stm32f0xx.c usbd_conf.c usbd_desc.c bsp24C02.c softI2C.c
software components: CMSIS:CORE 5.4.0
